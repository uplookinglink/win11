# Keil uVision project BLE_RTOS.uvprojx, settings and files
target SYD8811_FreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: padlock +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=1 uC99=1
  c include: ..\..\..\Lib;..\..\..\BLE;..\..\..\FreeRTOS\source\include;..\..\..\FreeRTOS\config;..\..\..\FreeRTOS\portable\ARM\SYD8811;..\..\..\FreeRTOS\portable\CMSIS\SYD8811;..\..\..\Include;..\application;..\profile;..\;..\task;..\..\..\Rtt
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Application
    ../: main.c config.h
    ../application/: softtimer.c lock.c lock.h aes.c aes.h aes_ecb.c aes_ecb.h ota.c ota.h Cat1.c udp.c
  group Task
    ../task/: softtimer_task.c softtimer_task.h
  group BLE
    ../application/: ble.c
  group Driver
    ../../../Driver/: debug.c gpio.c uart.c gpadc.c pwm.c
  group FreeRTOS
    ../../../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../FreeRTOS/source/portable/MemMang/: heap_4.c
    ../../../FreeRTOS/portable/ARM/SYD8811/: port.c
  group RTT
    ../../../Rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group Libraries
    ../../../Lib/: syd8811_ble_lib.lib AesEncryptDecrypt.lib
    ../application/: Syd8811_softtimer_lib.lib
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
